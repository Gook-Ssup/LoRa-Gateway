options:
  parameters:
    author: gnuradio-inc
    generate_options: qt_gui
    id: charm_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: loraGS_lora_preamble_detect_0
  id: loraGS_lora_preamble_detect
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_lora_detect_0
  id: loraGS_weak_lora_detect
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 915e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [loraGS_lora_preamble_detect_0, '0', qtgui_time_sink_x_0, '0']
- [loraGS_weak_lora_detect_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', loraGS_lora_preamble_detect_0, '0']
- [uhd_usrp_source_0, '0', loraGS_weak_lora_detect_0, '0']

metadata:
  file_format: 1

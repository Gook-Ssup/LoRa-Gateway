options:
  parameters:
    author: gnuradio-inc
    generate_options: qt_gui
    id: charm_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: loraGS_lora_preamble_detect_0
  id: loraGS_lora_preamble_detect
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {state: disabled}
- name: loraGS_weak_lora_detect_1
  id: loraGS_weak_lora_detect
  parameters:
    gatewayName: Lab1
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_lora_detect_1_0
  id: loraGS_weak_lora_detect
  parameters:
    gatewayName: Lab2
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: charm detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: charm detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: charm detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 915e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_sink_x_0_0_2, '0']
- [loraGS_lora_preamble_detect_0, '0', qtgui_sink_x_0_0_0, '0']
- [loraGS_weak_lora_detect_1, '0', blocks_throttle_0, '0']
- [loraGS_weak_lora_detect_1_0, '0', blocks_throttle_0_0, '0']
- [uhd_usrp_source_0, '0', loraGS_lora_preamble_detect_0, '0']
- [uhd_usrp_source_0, '0', loraGS_weak_lora_detect_1, '0']
- [uhd_usrp_source_0, '0', loraGS_weak_lora_detect_1_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0_1, '0']

metadata:
  file_format: 1

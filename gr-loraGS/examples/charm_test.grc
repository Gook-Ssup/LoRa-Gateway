options:
  parameters:
    author: gnuradio-inc
    generate_options: qt_gui
    id: charm_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: loraGS_lora_preamble_detect_0
  id: loraGS_lora_preamble_detect
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_lora_detect_0
  id: loraGS_weak_lora_detect
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 915e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5255
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5255
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_throttle_0, '0', zeromq_push_sink_0, '0']
- [loraGS_lora_preamble_detect_0, '0', qtgui_time_sink_x_0, '0']
- [loraGS_weak_lora_detect_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']
- [uhd_usrp_source_0, '0', loraGS_lora_preamble_detect_0, '0']
- [uhd_usrp_source_0, '0', loraGS_weak_lora_detect_0, '0']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: gnuradio-inc
    generate_options: qt_gui
    id: charm_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '3'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '50'
    noise_type: analog.GR_GAUSSIAN
    seed: '9'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '125000'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '125000'
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '125000'
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '256'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '256'
    type: ccc
  states: {state: disabled}
- name: loraGS_combine_signal_0
  id: loraGS_combine_signal
  parameters:
    preamble_length: '8'
    sf: '10'
  states: {}
- name: loraGS_lora_preamble_detect_0
  id: loraGS_lora_preamble_detect
  parameters:
    gatewayName: ''
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {state: disabled}
- name: loraGS_lora_preamble_detect_1
  id: loraGS_lora_preamble_detect
  parameters:
    gatewayName: origin
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {state: disabled}
- name: loraGS_lora_preamble_detect_1_0
  id: loraGS_lora_preamble_detect
  parameters:
    gatewayName: testing
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {state: disabled}
- name: loraGS_lora_preamble_detect_2
  id: loraGS_lora_preamble_detect
  parameters:
    gatewayName: Origin
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_lora_detect_1_0
  id: loraGS_weak_lora_detect
  parameters:
    gatewayName: GATE1
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_lora_detect_1_0_1
  id: loraGS_weak_lora_detect
  parameters:
    gatewayName: GATE2
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: qtgui_sink_x_0_0_2_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: lora detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: lora detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_2_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: lora detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: charm
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2_0_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: charm
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: lora detect
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: '125000'
    center_freq0: 915e6
    dc_offs_enb0: '""'
    dev_addr: '"serial=3189696"'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: '125000'
    center_freq0: 915e6
    dc_offs_enb0: '""'
    dev_addr: '"serial=3189EE7"'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0_0, '0', loraGS_lora_preamble_detect_0, '0']
- [blocks_add_xx_0_0, '0', loraGS_lora_preamble_detect_1, '0']
- [blocks_add_xx_0_0_0, '0', loraGS_weak_lora_detect_1_0_1, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle_0_0, '0', loraGS_lora_preamble_detect_2, '0']
- [blocks_throttle_0_0, '0', loraGS_weak_lora_detect_1_0, '0']
- [blocks_throttle_0_0, '0', loraGS_weak_lora_detect_1_0_1, '0']
- [blocks_throttle_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_add_xx_0_0, '1']
- [fir_filter_xxx_0, '0', loraGS_lora_preamble_detect_1_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_add_xx_0_0_0, '1']
- [loraGS_combine_signal_0, '0', qtgui_sink_x_0_0_2_0_0_0, '0']
- [loraGS_lora_preamble_detect_0, '0', qtgui_sink_x_0_0_2_0_0, '0']
- [loraGS_lora_preamble_detect_1, '0', qtgui_sink_x_0_0_2_0_0_0_0, '0']
- [loraGS_lora_preamble_detect_1_0, '0', qtgui_sink_x_0_0_2_0_0_0_0_0_0, '0']
- [loraGS_lora_preamble_detect_2, '0', qtgui_sink_x_0_0_2_0_0_0_1, '0']
- [loraGS_weak_lora_detect_1_0, '0', loraGS_combine_signal_0, '0']
- [loraGS_weak_lora_detect_1_0, '0', qtgui_sink_x_0_0_2_0_0_0_0_0, '0']
- [loraGS_weak_lora_detect_1_0_1, '0', loraGS_combine_signal_0, '1']
- [uhd_usrp_source_0_0_0, '0', fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0_1, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1

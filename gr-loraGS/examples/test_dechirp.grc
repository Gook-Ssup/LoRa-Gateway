options:
  parameters:
    author: gnuradio-inc
    generate_options: qt_gui
    id: test_dechirp
    output_language: python
    title: test_dechirp
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: loraGS_dechirp_source_0
  id: loraGS_dechirp_source
  parameters:
    sf: '10'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [loraGS_dechirp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1

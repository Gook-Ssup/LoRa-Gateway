options:
  parameters:
    generate_options: qt_gui
    id: lora_rx
    output_language: python
    title: LoRa RX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**SF
  states: {}
- name: RF_samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {state: disabled}
- name: RF_samp_rate
  id: variable
  parameters:
    value: int(8e6)
  states: {state: disabled}
- name: RF_samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '7'
  states: {}
- name: T
  id: variable
  parameters:
    value: float(M)/chan_bw
  states: {}
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: Attenuation
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.25'
    stop: '89.75'
    value: '20'
  states: {}
- name: chan_bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: chan_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: chan_margin
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: RF_samp_rate//(interp*chan_bw)
  states: {}
- name: file
  id: variable
  parameters:
    value: sig_dir+'/'+sig_name
  states: {}
- name: frac_decim
  id: variable
  parameters:
    value: RF_samp_rate/((RF_samp_rate//(interp*chan_bw))*(interp*chan_bw))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 4*chan_bw
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_syms
  id: variable
  parameters:
    value: '100'
  states: {}
- name: radio_offset
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: chan_bw
  states: {}
- name: sig_dir
  id: variable
  parameters:
    value: '''/home/amarquet/Documents/postdoc-imt/enseignements/projets-S5/2018/sdr/emetteur-recepteur-lora-sdr/scripts/signals'''
  states: {}
- name: sig_name
  id: variable
  parameters:
    value: '''zeros_SF'' + str(SF) + ''_CR4.raw'''
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: RF_samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: RF_samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: lora2_lora_preamble_detect_0_0
  id: lora2_lora_preamble_detect
  parameters:
    SF: '10'
    preamble_len: '8'
    thres: '1e-4'
  states: {state: disabled}
- name: loraGS_add2_0
  id: loraGS_add2
  parameters:
    sending_block: '0'
  states: {}
- name: loraGS_weak_index_0
  id: loraGS_weak_index
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_index_0_0
  id: loraGS_weak_index
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {}
- name: loraGS_weak_lora_detect_0
  id: loraGS_weak_lora_detect
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {state: disabled}
- name: loraGS_weak_test1_0
  id: loraGS_weak_test1
  parameters:
    preamble_len: '8'
    sf: '10'
    threshold: '1e-4'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (chan_bw + chan_margin)/2
    decim: decim
    gain: '200'
    samp_rate: RF_samp_rate
    type: fir_filter_ccf
    width: (chan_bw + chan_margin)/8
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (chan_bw + chan_margin)/2
    decim: decim
    gain: '200'
    samp_rate: RF_samp_rate
    type: fir_filter_ccf
    width: (chan_bw + chan_margin)/8
    win: firdes.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0.0'
    resamp_ratio: frac_decim
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0.0'
    resamp_ratio: frac_decim
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: RF_samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: RF_samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: 915e6
    freq1: 915e6
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: RF_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: chan_freq+freq_offset
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'False'
    dc_offset_auto_mode1: 'False'
    devname: hackrf
    gain_auto_mode0: 'True'
    gain_auto_mode1: 'False'
    lna_gain0: '0'
    manual_gain0: 'True'
    manual_gain1: 'True'
    mix_gain1: '10'
    nco_freq0: '0.0'
    overall_gain0: '0'
    samp_rate: RF_samp_rate
    sdrplay_biastee: 'True'
    tuner_gain1: '10'
    type: fc32
    vga_gain0: '0'
    vga_gain1: '10'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_sig
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: filtered_sig2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_sig
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_sig2
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5255
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5255
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_1, '0', zeromq_push_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [lora2_lora_preamble_detect_0_0, '0', qtgui_sink_x_0_0, '0']
- [loraGS_add2_0, '0', qtgui_sink_x_0, '0']
- [loraGS_weak_index_0, '0', loraGS_add2_0, '0']
- [loraGS_weak_index_0_0, '0', loraGS_add2_0, '1']
- [loraGS_weak_lora_detect_0, '0', qtgui_sink_x_0, '0']
- [loraGS_weak_test1_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_throttle_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '1', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', lora2_lora_preamble_detect_0_0, '0']
- [virtual_source_0, '0', loraGS_weak_index_0, '0']
- [virtual_source_0, '0', loraGS_weak_lora_detect_0, '0']
- [virtual_source_0, '0', loraGS_weak_test1_0, '0']
- [virtual_source_0_0, '0', loraGS_weak_index_0_0, '0']
- [zeromq_pull_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
